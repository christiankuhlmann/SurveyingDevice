## Codebase/sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_HZ=1000
CONFIG_FREERTOS_TASK_NOTIFICATION_ARRAY_ENTRIES=6
CONFIG_AUTOSTART_ARDUINO=y
```
